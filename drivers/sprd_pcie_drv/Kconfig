## drivers/sprd_pcie_drv/Kconfig
```kconfig
config SPRD_PCIE_DRIVER
    bool "Spreadtrum PCIe Driver"
    default n
    help
      a module for spreadtrum pcie driver.
```
