// SPDX-License-Identifier: (GPL-2.0+ OR MIT)
/*
 * Copyright (c) 2020 Rockchip Electronics Co., Ltd.
 *
 */
/* 主设备树配置文件 */
#include "rk3568-evb1-ddr4-v10.dtsi"
#include "rk3568-linux.dtsi"
